# Keil uVision project Demo.uvprojx, settings and files
target BaseComm (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DRAC-200E_BaseComm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_USED = 1
  c include: ..\..\App\include;..\..\Bsp\STM32F4_HAL\core;..\..\Bsp\STM32F4_HAL\include;..\..\Bsp\USER_HAL\include;..\..\User\include;..\..\Bsp\USMART\include;..\..\Bsp\LWIP\lwip-1.4.1\src\include;..\..\Bsp\LWIP\lwip-1.4.1\src\include\ipv4;..\..\Bsp\LWIP\lwip-1.4.1\src\include\netif;..\..\Bsp\LWIP\arch;..\..\Bsp\LWIP;..\..\Bsp\LWIP\lwip_app\lwip_comm;..\..\Ucosii\Config;..\..\Ucosii\Core;..\..\Ucosii\Port;..\..\Bsp\LWIP\lwip_app\tcp_client;..\..\Bsp\LWIP\lwip_app\udp;..\..\Bsp\LWIP\lwip_app\socket;..\..\Bsp\LWIP\mv88e6061_lib\switch\Include;..\..\Bsp\LWIP\mv88e6061_lib\switch\Include\h\driver;..\..\Bsp\LWIP\mv88e6061_lib\switch\Include\h\msApi;..\..\Bsp\LWIP\mv88e6061_lib\switch\Include\h\platform;..\..\Bsp\LWIP\mv88e6061_lib\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../../App/include/: app_cfg.h BaseCommProtocol.h BaseConfig.h InterComm.h OwnSocket.h SerlComm.h SysCommon.h
    ../../App/source/: app.c TaskCheck.c BaseCommProtocol.c BaseConfig.c InterComm.c OwnSocket.c SerlComm.c
  group Stm32Bsp
    ../../Bsp/STM32F4_HAL/source/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_pwr.c stm32f4x7_eth.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_flash.c
  group User
    ../../User/source/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../../User/include/: stm32f4xx_conf.h
  group UserBsp
    ../../Bsp/USER_HAL/source/: malloc.c tim3.c bsp.c delay.c rtc.c MathLib.c mv88e6061.c lan8720.c Usart.c Timer.c Flash_W25Q.c
    ../../Bsp/USER_HAL/include/: Usart.h Timer.h Flash_W25Q.h sys.h
  group core
    ../../Bsp/STM32F4_HAL/core/: startup_stm32f40_41xxx.s
    ../../App/include/: comdef.h
  group Lwip-Netif
    ../../Bsp/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group Lwip-Core
    ../../Bsp/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Bsp/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group Lwip-Api
    ../../Bsp/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip-Arch
    ../../Bsp/LWIP/arch/: sys_arch.c hw_arch.c
  group Lwip-App
    ../../Bsp/LWIP/lwip_app/lwip_comm/: lwip_comm.c lwipopts.h
    ../../Bsp/USER_HAL/source/: queue.c
    ../../Bsp/STM32F4_HAL/include/: stm32f4x7_eth_conf.h
  group Lwip-MvLib
    ../../Bsp/LWIP/mv88e6061_lib/switch/src/msapi/: gtAdvVct.c gtAVB.c gtBrgFdb.c gtBrgStp.c gtBrgStu.c gtBrgVlan.c gtBrgVtu.c gtCCPVT.c gtEvents.c gtHiddenReg.c gtMisc.c gtPage2Access.c gtPCSCtrl.c gtPhyCtrl.c gtPhyInt.c gtPIRL.c gtPIRL2.c gtPIRL3.c gtPolicy.c gtPortCtrl.c gtPortLed.c gtPortPav.c gtPortPrioMap.c gtPortRateCtrl.c gtPortRmon.c gtPortStat.c gtPortStatus.c gtPriTable.c gtPTP.c gtQosMap.c gtSerdesCtrl.c gtSysConfig.c gtSysCtrl.c gtSysStatus.c gtTCAM.c gtUtils.c gtVct.c gtVersion.c gtWeight.c
    ../../Bsp/LWIP/mv88e6061_lib/switch/src/platform/: gtDebug.c gtMiiSmiIf.c gtSem.c platformDeps.c
    ../../Bsp/LWIP/mv88e6061_lib/switch/src/driver/: gtDrvConfig.c gtDrvEvents.c gtHwCntl.c
  group Lwip-MvArch
    ../../Bsp/LWIP/mv88e6061_lib/arch/: mv88e6061_interface.c mv88e6061_phy.c
  group Ucosii-Core
    ../../Ucosii/Core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Ucosii-Port
    ../../Ucosii/Port/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Ucosii-Conf
    ../../Ucosii/Config/: includes.h os_cfg.h
  group TextNote
    ../../: ReleaseNote.txt
